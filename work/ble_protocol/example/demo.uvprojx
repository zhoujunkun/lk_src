# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ME32F030C8T6 Mesilicon
  pack: Mesilicon.ME32.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\myapp\inc;.\common\CoreSupport;.\common\DeviceSupport\arm\cmsdk;.\common\Drivers\include;..\queue;..\ble;..\..\ble_protocol
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group comm
    ./common/CoreSupport/: core_cm0.c
    ./common/DeviceSupport/arm/cmsdk/: system_CMSDK.c
    ./common/DeviceSupport/arm/cmsdk/Startup/arm/: startup_CMSDK_CM0.s
    ./common/Drivers/source/: sys.c uart.c
  group app
    ./myapp/src/: main.c
  group lk/app
    ../ble/: lk_ble.c lk_ble_ops.c
    ../queue/: ringQueue.c
