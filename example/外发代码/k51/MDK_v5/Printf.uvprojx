# Keil uVision project Printf.uvprojx, settings and files
target Printf (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,LIBRARY_VERSION,USE_FULL_ASSERT,AT_START_F415_V1_0
  c include: ..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Printf;..\AT32_Board;..\lk_src;..\lk_src\app;..\lk_src\board;..\lk_src\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415rct7.s
  group AT32Periph
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_tim.c at32f4xx_exti.c
  group README
    ../: readme.txt
  group lk/app/ble
    ../lk_src/app/ble/: lk_ble.c lk_ble_ops.c
    ../lk_src/app/queue/: ringQueue.c
  group lk/drv/433M
    ../lk_src/driver/drv433m/: lk_433m.c
  group lk/app/task
    ../lk_src/app/task/: lk_task.c
  group lk/board/k51
    ../lk_src/board/k51/: lk_board.c
